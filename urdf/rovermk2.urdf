Commit message: Collision Fixes

File: urdf/rovermk2.urdf (robot description, URDF)
Before this commit: robot rovermk2, 11 links, 10 joints
Links:
- link base_link: geometry collision box size=0.28 0.35 0.15; visual mesh filename=package://rovermk2_description/meshes/base_link.STL
